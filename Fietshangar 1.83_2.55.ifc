Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 40ac5fb9-2056-4d52-bbb5-813c183e1f7d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: 0001
Time: 2026-01-06T21:05:00+04:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.4.427 (ENU) - IFC 24.0.4.427

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (7)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (m)
000.basement plan | 000.basement plan | -2.6
00.ground floor plan | 00.ground floor plan | 0
01.first floor plan | 01.first floor plan | 4
02.second floor plan | 02.second floor plan | 7.6
03.third floor plan | 03.third floor plan | 11.2
04. forth floor plan | 04. forth floor plan | 14.8
05. fifth floor plan | 05. fifth floor plan | 18.4

# IfcBuildingElementProxy: Fietshangar 1.83_2.55_bike:Fietshangar 1.83 (4 bikes), Fietshangar 1.83_2.55_bike:Fietshangar 1.83 (4 bikes):356466
In: 00.ground floor plan
Type - Material: Galvanized
Type - Pset_ProductRequirements - Category: Parking
Type - Pset_ProvisionForVoid - Width: 1.83 m; Height: 1.5 m
Pset_BuildingElementProxyCommon - Reference: Fietshangar 1.83 (4 bikes); sets with these values: 2
